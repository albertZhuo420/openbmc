FILESEXTRAPATHS:prepend := "${THISDIR}/linux-aspeed:"
SRC_URI += "file://pwfb.cfg \
            file://0001-add-viscore-pwfb-machine-s-dts-file.patch \
            "
# SRC_URI += "file://tiogapass.cfg"
