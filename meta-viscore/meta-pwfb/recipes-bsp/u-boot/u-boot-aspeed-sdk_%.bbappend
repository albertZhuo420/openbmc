FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://pwfb.cfg"
# SRC_URI += "file://tiogapass.cfg"
