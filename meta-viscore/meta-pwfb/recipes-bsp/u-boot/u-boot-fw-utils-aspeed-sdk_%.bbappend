FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-aspeed-sdk:"
SRC_URI += "file://pwfb.cfg"
# SRC_URI += "file://tiogapass.cfg"
